# Keil uVision project test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../集成/集创赛参考代码/DetectHumanFaces-master/software/: CM3DS_MPS2.h CM3DS_MPS2_driver.c CM3DS_MPS2_driver.h main.c picornt.c picornt.h Retarget.c RGBprocess.h
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Device:Startup 1.2.2, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
